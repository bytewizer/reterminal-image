RDEPENDS:${PN}:append = " wpa-supplicant "
PACKAGECONFIG:append = " networkd resolved"